FILESPATH_prepend := "${THISDIR}/${PN}:${THISDIR}/files:"

SRC_URI += "file://sw-description-${MACHINE}"
